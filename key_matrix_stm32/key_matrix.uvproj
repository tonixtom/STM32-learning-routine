# Keil uVision project key_matrix.uvproj, settings and files
target key_matrix (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103VB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: key_matrix +hex
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\Code
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group User
    ./Code/: stm32f10x_it.c main.c
  group FWLib
    ./Code/: STM32F10xR.LIB
  group RVMDK
    ./Code/: stm32f10x_vector.s
