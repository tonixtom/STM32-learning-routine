# Keil uVision project first.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F401RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IROM(0x08000000,0x00080000) IRAM(0x20000000,0x00018000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: first +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: .\FWlib\inc;.\FWlib\src;.\user
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group user
    ./user/: main.c
software components: CMSIS:CORE 5.1.2, Device:Startup 2.6.3
